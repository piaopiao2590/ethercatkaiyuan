# Keil uVision project ethercat2.uvprojx, settings and files
target ethercat2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ethercat2 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE;..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE\bsp\inc;..\HARDWARE\module\md_inc;..\HARDWARE;..\ThirdPart\Ethercat\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_dma.c stm32f4xx_flash.c
  group HARDWARE/bsp
    ../HARDWARE/bsp/src/: bsp_sys.c bsp_systick.c bsp_time.c bsp_spi.c
  group HARDWARE/moudle
    ../HARDWARE/module/md_src/: md_app.c md_ethercat.c
  group Ethercat
    ../ThirdPart/Ethercat/src/: bootmode.c coeappl.c ecatappl.c ecatcoe.c ecatfoe.c ecatport.c ecatslv.c foeappl.c mailbox.c myapp.c objdef.c sdoserv.c bootloaderappl.c
